Commit message: transform

File: mesh.urdf (robot description, URDF)
Before this commit: robot scene, 1 links, 0 joints
Links:
- link scene: geometry visual mesh filename=./scene.dae scale=0.1 0.1 0.1
